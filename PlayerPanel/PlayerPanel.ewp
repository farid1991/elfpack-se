# IAR project PlayerPanel.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  group (top)
    ../classlib/: cl.cpp
    ./: conf_loader.cpp config_data.c CurrentTrack.c decoder.c draw.cpp draw.h main.cpp metadata.c metadata.h migrate.cpp mybook.cpp mybook.h mydisp.cpp mydisp.h rand.c
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
