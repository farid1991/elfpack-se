# IAR project Lines.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: cfg_items.h conf_loader.cpp conf_loader.h config_data.c config_data.h confitems.h game.cpp game.h gui.cpp gui.h lang.cpp lang.h lists.h log.cpp log.h main.cpp main.h menu.cpp menu.h random.cpp random.h resource.cpp resource.h util.h utils.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
