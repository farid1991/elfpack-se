# IAR project Standby Mode.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: RUS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USEZLIB; RUS; OLDFUNCTIONS
  group (top)
    ../C++/: _cpp2.cpp
    ./: AlarmInfo.c AppInfo.c AppInfo.h BattTempInfo.c binclock.cpp CallsInfo.c compat.cpp conf_loader.cpp config_data.c crc.cpp CustomMsg.c div.r79 field.cpp file.cpp frame.cpp frametype.cpp genre.cpp header.cpp headerReader.cpp HeapInfo.c Images.c latin1.cpp main.c MediaInfo.c MemInfo.c merge.c merge_from_v210.c merge_from_v211.c merge_from_v212.c merge_from_v213.c merge_from_v214.c merge_from_v215.c merge_from_v216.c merge_from_v217.c merge_from_v27.c merge_from_v28.c merge_from_v29.c NetworkInfo.c OperatorInfo.c parse.cpp phone.c phone.h render.cpp splitutils.c StatusInfo.c StatusInfo.h strncmpi.c tag.cpp tagReader.cpp TimeDateInfo.c towlower.c towupper.c ucs4.cpp utf16.cpp utf8.cpp util.cpp
    ../include/: func.asm
