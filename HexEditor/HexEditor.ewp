# IAR project HexEditor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: ..\include\1.xcl
  group (top)
    ./: conf_loader.cpp config_data.c Graphics.c LNGparser.c main.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp
