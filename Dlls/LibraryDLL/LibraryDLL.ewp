# IAR project LibraryDLL.ewp, settings and files
configuration C510_R1FA035_Orange (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: "prebuild.bat" "$PROJ_DIR$" "$TARGET_DIR$"
  XLINK.XclFile: ..\..\include\1.xcl
configuration C510_R1HA035 (ARM)
  as the first configuration, except:
configuration C702_R3EF001 (ARM)
  as the first configuration, except:
configuration C901_R1GA028 (ARM)
  as the first configuration, except:
configuration C902_R3EG004AO (ARM)
  as the first configuration, except:
configuration C902_R3EG004AS (ARM)
  as the first configuration, except:
configuration C903_R1GA028 (ARM)
  as the first configuration, except:
configuration C905_R1FA035 (ARM)
  as the first configuration, except:
configuration F100_R1HA035 (ARM)
  as the first configuration, except:
configuration G502_R1FA037_Hutchison (ARM)
  as the first configuration, except:
configuration Generic (ARM)
  as the first configuration, except:
configuration J105_R1GA026_Orange (ARM)
  as the first configuration, except:
configuration J105_R1HA035 (ARM)
  as the first configuration, except:
configuration K630_R1FA032 (ARM)
  as the first configuration, except:
configuration K660_R1FA037_Hutchison (ARM)
  as the first configuration, except:
configuration K850_R1FA035 (ARM)
  as the first configuration, except:
configuration T700_R3EG004 (ARM)
  as the first configuration, except:
configuration T707_R1FA035 (ARM)
  as the first configuration, except:
configuration T715_R1GA026 (ARM)
  as the first configuration, except:
configuration T715_R1HA035 (ARM)
  as the first configuration, except:
configuration W350_R11CA002 (ARM)
  as the first configuration, except:
configuration W508_R1FA035 (ARM)
  as the first configuration, except:
configuration W595_R3EF001 (ARM)
  as the first configuration, except:
configuration W595_R3EG004_Orange (ARM)
  as the first configuration, except:
configuration W705_R1GA031 (ARM)
  as the first configuration, except:
configuration W715_R1GA030 (ARM)
  as the first configuration, except:
configuration W760_R3EF001 (ARM)
  as the first configuration, except:
configuration W760_R3EM001 (ARM)
  as the first configuration, except:
configuration W890_R1FA035 (ARM)
  as the first configuration, except:
configuration W902_R3EG004 (ARM)
  as the first configuration, except:
configuration W910_R1FA037 (ARM)
  as the first configuration, except:
configuration W980_R3EG004 (ARM)
  as the first configuration, except:
configuration W995_R1GA026 (ARM)
  as the first configuration, except:
configuration W995_R1HA035 (ARM)
  as the first configuration, except:
configuration Z770_R1FA035 (ARM)
  as the first configuration, except:
  group (top)
    ../../C++/: _cpp2.cpp
    ../../include/: func.asm
    export/: LibraryDLL.h
    ./: main.c vkp.cpp vkp.h
